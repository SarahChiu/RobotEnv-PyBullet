Commit message: fix env bug

File: src/data/door.urdf (robot description, URDF)
Before this commit: robot urdf_door, 4 links, 3 joints
Links:
- link childA: mass 1.0 -> 0.1
- link doorknob: mass 0.2 -> 0.01
