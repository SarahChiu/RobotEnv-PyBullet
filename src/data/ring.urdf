Commit message: fix ring on peg env

File: src/data/ring.urdf (robot description, URDF)
Before this commit: robot ring, 1 links, 0 joints
Links:
- link ring_link: geometry collision box size=0.40 0.025 0.03; collision box size=0.40 0.025 0.03
